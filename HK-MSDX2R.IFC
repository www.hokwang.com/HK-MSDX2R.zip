Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-MSDX2R.IFC
Time: 2022-01-04T07:25:03
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 950SA導光柱
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: C529-1鎖頭_Default_1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: MSD外殼-LOVAIR
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD背板
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 下圓盤
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 圓桶型透視窗_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 給皂機半牙螺絲 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 給皂機半牙螺絲B (3)
In: Default Storey
PredefinedType: ELEMENT
Name | Material
給皂機半牙螺絲B | Steel
2 x 給皂機半牙螺絲B | 0

# IfcBuildingElementProxy: 起泡頭
In: Default Storey
PredefinedType: ELEMENT; Material: 0
